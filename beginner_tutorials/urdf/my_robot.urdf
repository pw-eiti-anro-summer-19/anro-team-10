Commit message: new commit

File: beginner_tutorials/urdf/my_robot.urdf (robot description, URDF)
Before this commit: robot myfirst, 4 links, 3 joints
Joints:
- joint base_to_link_1: limit (none) -> lower=-1 upper=1 effort=1000.0 velocity=0.5; type continuous -> revolute
